EXTRA_OECONF:append = " --disable-shared --disable-mini-gmp --disable-gcov --disable-documentation --enable-static"
